# License exception for rubikpi3's boot firmware in qcom-multimedia-image,
# whose meta-qcom-distro append sets INCOMPATIBLE_LICENSE. Parsed only when
# meta-qcom-distro is in the build (BBFILES_DYNAMIC in conf/layer.conf).
INCOMPATIBLE_LICENSE_EXCEPTIONS:append:rubikpi3 = " firmware-qcom-boot-rubikpi3:LicenseRef-LICENSE.qcom-2"
